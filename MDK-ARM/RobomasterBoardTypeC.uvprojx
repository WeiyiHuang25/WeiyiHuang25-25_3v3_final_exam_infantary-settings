# Keil uVision project RobomasterBoardTypeC.uvprojx, settings and files
target RobomasterBoardTypeC (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: RobomasterBoardTypeC +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=1
  c define: USE_HAL_DRIVER,STM32F407xx,USE_SEML_LIB
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/ST/ARM/DSP/Inc;../SEML;../SEML/Drivers/hal;../SEML/Drivers/hal/Interface;../SEML/Drivers/bsp/BMI088;../SEML/Drivers/bsp/WS281x;../SEML/Middlewares/System;../SEML/Middlewares/Solution;../SEML/Middlewares/Solution/AHRS;../SEML/Middlewares/Solution/AHRS/Mahony;../SEML/Middlewares/DataStructure;../SEML/Middlewares/Control;../SEML/Middlewares/Communications;../SEML/App/Robo;../SEML/Middlewares/math
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c gpio.c adc.c can.c crc.c dac.c dma.c i2c.c rng.c rtc.c spi.c tim.c usart.c usb_device.c usbd_conf.c usbd_desc.c usbd_cdc_if.c stm32f4xx_it.c stm32f4xx_hal_msp.c CRC8_CRC16.c
    ../Inc/: CRC8_CRC16.h
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_can.c stm32f4xx_hal_crc.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group SEML\Drivers
    ../SEML/Drivers/hal/Interface/: can_if.c gpio_if.c i2c_if.c pwm_if.c spi_if.c uart_if.c
    ../SEML/Drivers/hal/: button.c buzzer.c Motor.c
    ../SEML/Drivers/bsp/BMI088/: BMI088driver.c
    ../SEML/Drivers/bsp/WS281x/: WS281x.c
  group SEML\Middlewares\System
    ../SEML/Middlewares/System/: event_os.c message.c timer.c
    ../SEML/: SEML_common.c
  group SEML\Middlewares\Communications
    ../SEML/Middlewares/Communications/: DR16_Remote.c SuperCap.h reference.h reference.c SuperCap.c RC_Ctrl_Key.h DR16_Remote.h RC_Ctrl_Key.c
  group SEML\Middlewares\math
    ../SEML/Middlewares/math/: math_common.c math_CRC.c math_fast.c math_filter.c math_matrix.c math_Quaternion.c math_CRC.h math_fast.h math_filter.h math_matrix.h math_quaternion.h
  group SEML\Middlewares\Sol
    ../SEML/Middlewares/Control/: PID.c
    ../SEML/Middlewares/DataStructure/: queue.c
    ../SEML/Middlewares/Solution/: chassis.c chassis_power_control.c chassis_power_control.h
    ../SEML/Middlewares/Solution/AHRS/: AHRS.c
    ../SEML/Middlewares/Solution/AHRS/Mahony/: Mahony.c
  group SEML\App
    ../SEML/App/Robo/: Robo_Chassis.c Robo_Control.c Robo_gimbal.c Robo_common.c Robo_Shoot.c Robo_Shoot.h Robo_AA.c Robo_USB.c Robo_AA.h Robo_USB.h pid.h pid.c EzTuner.h
    ../SEML/Middlewares/Communications/: Tamagawa.h Tamagawa.c HT_Moter.c Dji_Motor.c DMPower.c
  group Middlewares/Library/DSP Library/DSP Library
    ../Middlewares/ST/ARM/DSP/Lib/: arm_cortexM4l_math.lib
software components: CMSIS:CORE 4.3.0
